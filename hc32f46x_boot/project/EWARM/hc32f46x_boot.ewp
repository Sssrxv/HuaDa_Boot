# IAR project hc32f46x_boot.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: HC32F46x
  ICCARM.CCIncludePath2: ..\..\app\iap; ..\..\common; ..\..\driver; ..\..\midware
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: hc32f46x_boot.bin
  ILINK.IlinkOutputFile: hc32f46x_boot.out
  ILINK.IlinkIcfFile: config\HC32F46x_boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  General.CoreVariant: 35
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: hc32f46x_boot.srec
  ILINK.IlinkIcfFile: hc32f46x.icf
  group app
    ../../app/iap/: iap.c modem.c
  group common
    ../../common/: hc32f46x_icg.c system_hc32f46x.c
    ./: startup_hc32f46x.s
  group driver
    ../../driver/: basic.c flash.c uart.c
  group source
    ../source/: main.c
