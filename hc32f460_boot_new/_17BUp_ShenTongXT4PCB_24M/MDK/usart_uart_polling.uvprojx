# Keil uVision project usart_uart_polling.uvprojx, settings and files
target usart_uart_polling_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32A460PETB HDSC
  pack: HDSC.HC32A460.1.0.0
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usart_uart_polling +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F460,USE_DDL_DRIVER,
  c include: ../source;..\CMDrivers\cmsis\Device\HDSC\hc32f4xx\Include;..\CMDrivers\cmsis\Include;..\BSP;..\APP;..\Drivers\inc;..\Hal
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
  group cmsis
    ../CMDrivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
    ../CMDrivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group source
    ../source/: main.c
  group driver
    ../Drivers/src/: hc32_ll.c hc32_ll_adc.c hc32_ll_aes.c hc32_ll_aos.c hc32_ll_can.c hc32_ll_clk.c hc32_ll_cmp.c hc32_ll_crc.c hc32_ll_dbgc.c hc32_ll_dcu.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_emb.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_hash.c hc32_ll_i2c.c hc32_ll_i2s.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_mpu.c hc32_ll_ots.c hc32_ll_pwc.c hc32_ll_qspi.c hc32_ll_rmu.c hc32_ll_rtc.c hc32_ll_sdioc.c hc32_ll_spi.c hc32_ll_sram.c hc32_ll_swdt.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_tmra.c hc32_ll_trng.c hc32_ll_usart.c hc32_ll_utility.c hc32_ll_wdt.c hc32f460_ll_interrupts_share.c hc32_ll_keyscan.c
  group ev_hc32f460_lqfp100_v2
    ../BSP/: ev_hc32f460_lqfp100_v2.c
  group BSP
    ../BSP/: uart.c time.c flash.c
  group HAL
    ../Hal/: hal_tp_cfg.c hal_uart.c hal_uart_tp_cfg.c multi_cyc_fifo.c hal_uart_tp.c hal_tp.c hal_crc.c hal_flash.c hal_flash_cfg.c
  group APP
    ../APP/: AES.c app_bootloader.c app_flash.c app_uds.c app_uds_alg.c app_uds_cfg.c
target usart_uart_polling_Release (ARM-ADS)
  device: HC32A460PETB HDSC
  pack: HDSC.HC32A460.1.0.0
  cpu: as above
  output: usart_uart_polling +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HC32F460,USE_DDL_DRIVER,
  c include: ..\source;../../../../../../drivers/cmsis/Device/HDSC/hc32f4xx/Include;../../../../../../drivers/cmsis/Include;../../../../../../drivers/hc32_ll_driver/inc;../../../../../../drivers/bsp/ev_hc32f460_lqfp100_v2;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F460xE.sct
  link misc: --keep=*Handler
