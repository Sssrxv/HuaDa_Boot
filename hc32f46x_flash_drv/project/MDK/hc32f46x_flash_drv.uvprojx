# Keil uVision project hc32f46x_flash_drv.uvprojx, settings and files
target hc32f46x_flash_drv (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32A460PETB HDSC
  pack: HDSC.HC32A460.1.0.0
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32f46x_flash_drv +hex
  AfterMake: fromelf  --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: HC32F46x
  c misc: --diag_suppress=186,66
  c include: ..\..\app\iap;..\..\common;..\..\driver;..\..\midware;..\source
  library: MicroLIB
  memory RVCT4: ROM 0x70000 size 0x10000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\output\release\hc32f46x_boot.sct
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f46x.s
    ../../common/: system_hc32f46x.c hc32f46x_icg.c
  group source
    ../source/: main.c NVM_Flash.c
  group driver
    ../../driver/: basic.c flash.c uart.c flash_sys.c
  group app
    ../../app/iap/: iap.c
software components: CMSIS:CORE 5.0.1
